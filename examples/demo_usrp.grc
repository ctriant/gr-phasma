<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>demo_usrp</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>active_mod</value></param>
<param><key>value</key><value>3</value></param>
<param><key>label0</key><value>BPSK</value></param>
<param><key>label1</key><value>QPSK</value></param>
<param><key>label2</key><value>PSK8</value></param>
<param><key>label3</key><value>GMSK</value></param>
<param><key>num_opts</key><value>4</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>option3</key><value>3</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_bw</value></param>
<param><key>value</key><value>10e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_num</value></param>
<param><key>value</key><value>int(samp_rate / channel_bw)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>int((samp_rate * ifft_size) / channel_bw)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_range</value></param>
<param><key>value</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-samp_rate/4</value></param>
<param><key>step</key><value>1e3</value></param>
<param><key>stop</key><value>samp_rate/4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ifft_size</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>power_switch</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>true</key><value>0.65</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>35</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>20</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>40</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>taps_0</value></param>
<param><key>cutoff_freq</key><value>1/4.0</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>1.0</value></param>
<param><key>width</key><value>0.055</value></param>
<param><key>win</key><value>firdes.WIN_RECTANGULAR</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/ctriant/over_the_air/xlating_phasma/mixed_train_8/psk8.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>(1.0)/fft_size</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>blocks_probe_rate_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>mintime</key><value>150</value></param>
<param><key>alpha</key><value>0.15</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts // 2</value></param>
<param><key>loop_bw</key><value>2*math.pi / 100</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>16</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_1</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>freq_xlating_fft_filter_ccc</key>
<param><key>id</key><value>freq_xlating_fft_filter_ccc_0</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import time</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>phasma_eigenvalue_signal_detector</key>
<param><key>id</key><value>phasma_eigenvalue_signal_detector_0</value></param>
<param><key>actual_bw</key><value>samp_rate</value></param>
<param><key>eigen_samples</key><value>fft_size/4</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>pfa</key><value>0.01</value></param>
<param><key>noise_floor_est_cnt</key><value>200</value></param>
<param><key>sampling_rate</key><value>samp_rate</value></param>
<param><key>smoothing_factor</key><value>4</value></param>
</block>
<block>
<key>phasma_ncurses_console</key>
<param><key>id</key><value>phasma_ncurses_console_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>labels</key><value>("BPSK", "QPSK", "PSK8", "GMSK")</value></param>
</block>
<block>
<key>phasma_opencv_predict</key>
<param><key>id</key><value>phasma_opencv_predict_0</value></param>
<param><key>active_mod</key><value>active_mod</value></param>
<param><key>classifier_type</key><value>0</value></param>
<param><key>debug_mode</key><value>True</value></param>
<param><key>nlabels</key><value>4</value></param>
<param><key>data_type</key><value>3</value></param>
<param><key>labels</key><value>(0,1,2,3)</value></param>
<param><key>metafile</key><value></value></param>
<param><key>history_size</key><value>100</value></param>
<param><key>npredictors</key><value>1024</value></param>
<param><key>filename</key><value>/home/ctriant/xlating_phasma_mixed.xml</value></param>
</block>
<block>
<key>phasma_sigmf_debug</key>
<param><key>id</key><value>phasma_sigmf_debug_0</value></param>
<param><key>conseq_channel_num</key><value>channel_num</value></param>
<param><key>ifft_size</key><value>ifft_size</value></param>
</block>
<block>
<key>phasma_signal_separator</key>
<param><key>id</key><value>phasma_signal_separator_0</value></param>
<param><key>channel_bw</key><value>channel_bw</value></param>
<param><key>threshold_db</key><value>-96</value></param>
<param><key>threshold_margin_db</key><value>4</value></param>
<param><key>center_freq</key><value>-samp_rate/2</value></param>
<param><key>ifft_size</key><value>ifft_size</value></param>
<param><key>min_sig_bw</key><value>15e3</value></param>
<param><key>sig_num</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>signal_duration</key><value>100e-3</value></param>
<param><key>silence_guardband</key><value>3e3</value></param>
<param><key>taps</key><value>[5.821550740179787e-18, 0.0002798568457365036, -0.000601654639467597, 0.0009776194347068667, -0.0013943456578999758, 0.001803029328584671, -0.0021169704850763083, 0.0022183191031217575, -0.0019744711462408304, 0.0012627167161554098, -1.0874462094118149e-17, -0.001826730789616704, 0.00413485849276185, -0.006730340421199799, 0.0093061663210392, -0.01145764160901308, 0.012714805081486702, -0.012589770369231701, 0.010634293779730797, -0.006500936113297939, 2.701076068539024e-17, 0.00885568093508482, -0.019825076684355736, 0.03243735060095787, -0.04601643979549408, 0.05973070114850998, -0.07266323268413544, 0.08389569818973541, -0.09259632229804993, 0.09810233116149902, 0.8998810052871704, 0.09810233116149902, -0.09259632229804993, 0.08389569818973541, -0.07266323268413544, 0.05973070114850998, -0.04601643979549408, 0.03243735060095787, -0.019825076684355736, 0.00885568093508482, 2.701076068539024e-17, -0.006500936113297939, 0.010634293779730797, -0.012589770369231701, 0.012714805081486702, -0.01145764160901308, 0.0093061663210392, -0.006730340421199799, 0.00413485849276185, -0.001826730789616704, -1.0874462094118149e-17, 0.0012627167161554098, -0.0019744711462408304, 0.0022183191031217575, -0.0021169704850763083, 0.001803029328584671, -0.0013943456578999758, 0.0009776194347068667, -0.000601654639467597, 0.0002798568457365036, 5.821550740179787e-18]</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>name</key><value>"Before Extraction"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.5</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>name</key><value>"After Extraction"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.5</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"After Extraction"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.0010</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>5e9 </value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>"serial=EFR04ZDBT"</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>usrp_samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_0_0</source_block_id><sink_block_id>phasma_signal_separator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_probe_rate_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>rate</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_1</source_block_id><sink_block_id>fft_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_1</source_block_id><sink_block_id>blocks_vector_to_stream_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phasma_eigenvalue_signal_detector_0</source_block_id><sink_block_id>phasma_signal_separator_0</sink_block_id><source_key>threshold</source_key><sink_key>threshold_rcv</sink_key></connection>
<connection><source_block_id>phasma_opencv_predict_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>classification</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>phasma_opencv_predict_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>classification</source_key><sink_key>store</sink_key></connection>
<connection><source_block_id>phasma_opencv_predict_0</source_block_id><sink_block_id>phasma_ncurses_console_0</sink_block_id><source_key>print</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>phasma_sigmf_debug_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phasma_sigmf_debug_0</source_block_id><sink_block_id>blocks_probe_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phasma_sigmf_debug_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phasma_sigmf_debug_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phasma_sigmf_debug_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phasma_signal_separator_0</source_block_id><sink_block_id>phasma_opencv_predict_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>phasma_signal_separator_0</source_block_id><sink_block_id>phasma_sigmf_debug_0</sink_block_id><source_key>out</source_key><sink_key>sigmf</sink_key></connection>
<connection><source_block_id>phasma_signal_separator_0</source_block_id><sink_block_id>phasma_ncurses_console_0</sink_block_id><source_key>print</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>phasma_eigenvalue_signal_detector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>phasma_signal_separator_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
