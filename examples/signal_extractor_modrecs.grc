<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>signal_extractor_modrecs</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>500*ifft_size</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_range</value></param>
<param><key>value</key><value>1e9</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1e9</value></param>
<param><key>step</key><value>100e6</value></param>
<param><key>stop</key><value>2.5e9</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_range_coarse</value></param>
<param><key>value</key><value>-2e6</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-5e6</value></param>
<param><key>step</key><value>20e3</value></param>
<param><key>stop</key><value>5e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_range_fine</value></param>
<param><key>value</key><value>1000000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-5e6</value></param>
<param><key>step</key><value>1e3</value></param>
<param><key>stop</key><value>5e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ifft_size</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>power_switch</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>taps</value></param>
<param><key>cutoff_freq</key><value>0.4</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>1.0</value></param>
<param><key>width</key><value>0.495</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_0</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/ctriant/modrec.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>(1.0)/fft_size</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_1</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>phasma_eigenvalue_signal_detector</key>
<param><key>id</key><value>phasma_eigenvalue_signal_detector_0</value></param>
<param><key>actual_bw</key><value>samp_rate</value></param>
<param><key>eigen_samples</key><value>128</value></param>
<param><key>fft_size</key><value>32000</value></param>
<param><key>pfa</key><value>0.01</value></param>
<param><key>noise_floor_est_cnt</key><value>300</value></param>
<param><key>sampling_rate</key><value>samp_rate</value></param>
<param><key>smoothing_factor</key><value>10</value></param>
</block>
<block>
<key>phasma_opencv_predict</key>
<param><key>id</key><value>phasma_opencv_predict_0</value></param>
<param><key>classifier_type</key><value>0</value></param>
<param><key>nlabels</key><value>7</value></param>
<param><key>data_type</key><value>3</value></param>
<param><key>metafile</key><value>/home/ctriant/output.meta</value></param>
<param><key>npredictors</key><value>512</value></param>
<param><key>filename</key><value>/home/ctriant/model.xml</value></param>
</block>
<block>
<key>phasma_sigmf_debug</key>
<param><key>id</key><value>phasma_sigmf_debug_0</value></param>
<param><key>conseq_channel_num</key><value>500</value></param>
<param><key>ifft_size</key><value>ifft_size</value></param>
</block>
<block>
<key>phasma_signal_extractor</key>
<param><key>id</key><value>phasma_signal_extractor_1</value></param>
<param><key>channel_bw</key><value>20e3</value></param>
<param><key>threshold_db</key><value>-97</value></param>
<param><key>threshold_margin_db</key><value>3</value></param>
<param><key>center_freq</key><value>3190e6</value></param>
<param><key>ifft_size</key><value>64</value></param>
<param><key>min_sig_bw</key><value>20e3</value></param>
<param><key>sig_num</key><value>100</value></param>
<param><key>samp_rate</key><value>10e6</value></param>
<param><key>signal_duration</key><value>100e-3</value></param>
<param><key>silence_guardband</key><value>1e3</value></param>
<param><key>taps</key><value>taps</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>3195e6</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>name</key><value>"Over ther air"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.5</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>""Extracted signal"</value></param>
<param><key>size</key><value>4096</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>1e9</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>25</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_0_0</source_block_id><sink_block_id>phasma_signal_extractor_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>phasma_eigenvalue_signal_detector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>phasma_signal_extractor_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_1</source_block_id><sink_block_id>fft_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_1</source_block_id><sink_block_id>blocks_vector_to_stream_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phasma_eigenvalue_signal_detector_0</source_block_id><sink_block_id>phasma_signal_extractor_1</sink_block_id><source_key>threshold</source_key><sink_key>threshold_rcv</sink_key></connection>
<connection><source_block_id>phasma_opencv_predict_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>classification</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>phasma_sigmf_debug_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phasma_signal_extractor_1</source_block_id><sink_block_id>phasma_opencv_predict_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>phasma_signal_extractor_1</source_block_id><sink_block_id>phasma_sigmf_debug_0</sink_block_id><source_key>out</source_key><sink_key>sigmf</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>phasma_eigenvalue_signal_detector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>phasma_signal_extractor_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
