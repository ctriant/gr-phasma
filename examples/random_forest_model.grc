<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>random_forest_model</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise_amp</value></param>
<param><key>value</key><value>0.01</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_1</value></param>
<param><key>file</key><value>/home/ctriant/captures/bpsk_01.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_1_0</value></param>
<param><key>file</key><value>/home/ctriant/captures/bpsk_1.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_1_0_0</value></param>
<param><key>file</key><value>/home/ctriant/captures/qpsk_1.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_1_0_1</value></param>
<param><key>file</key><value>/home/ctriant/captures/gfsk_1.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_1_0_1_0</value></param>
<param><key>file</key><value>/home/ctriant/captures/gmsk_1.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_1_1</value></param>
<param><key>file</key><value>/home/ctriant/captures/bpsk_3.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_1_1_0</value></param>
<param><key>file</key><value>/home/ctriant/captures/qpsk_3.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_1_2</value></param>
<param><key>file</key><value>/home/ctriant/captures/qpsk_01.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_1_3</value></param>
<param><key>file</key><value>/home/ctriant/captures/gfsk_01.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_1_3_0</value></param>
<param><key>file</key><value>/home/ctriant/captures/gmsk_01.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>phasma_rforest_model</key>
<param><key>id</key><value>phasma_rforest_model_0</value></param>
<param><key>active_var_count</key><value>0</value></param>
<param><key>calc_var_importance</key><value>False</value></param>
<param><key>nobservations</key><value>50000</value></param>
<param><key>filename</key><value>/home/ctriant/multi_snr.xml</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ninport</key><value>10</value></param>
<param><key>labels</key><value>(0, 0, 0, 1, 1, 1, 2, 2, 3, 3)</value></param>
<param><key>max_categories</key><value>10</value></param>
<param><key>max_depth</key><value>10</value></param>
<param><key>max_iter</key><value>600</value></param>
<param><key>min_sample_count</key><value>100</value></param>
<param><key>npredictors</key><value>768</value></param>
<param><key>regression_accu</key><value>0</value></param>
<param><key>use_surrogates</key><value>False</value></param>
</block>
<connection><source_block_id>blocks_file_source_1</source_block_id><sink_block_id>phasma_rforest_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_1_0</source_block_id><sink_block_id>phasma_rforest_model_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_file_source_1_0_0</source_block_id><sink_block_id>phasma_rforest_model_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_file_source_1_0_1</source_block_id><sink_block_id>phasma_rforest_model_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>blocks_file_source_1_0_1_0</source_block_id><sink_block_id>phasma_rforest_model_0</sink_block_id><source_key>0</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>blocks_file_source_1_1</source_block_id><sink_block_id>phasma_rforest_model_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_file_source_1_1_0</source_block_id><sink_block_id>phasma_rforest_model_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_file_source_1_2</source_block_id><sink_block_id>phasma_rforest_model_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_file_source_1_3</source_block_id><sink_block_id>phasma_rforest_model_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>blocks_file_source_1_3_0</source_block_id><sink_block_id>phasma_rforest_model_0</sink_block_id><source_key>0</source_key><sink_key>8</sink_key></connection>
</flow_graph>
